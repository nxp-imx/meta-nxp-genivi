IMAGE_INSTALL_append = " packagegroup-fsl-tools-testapps packagegroup-fsl-tools-gpu"
