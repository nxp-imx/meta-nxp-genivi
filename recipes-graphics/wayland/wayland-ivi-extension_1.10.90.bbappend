SRCREV = "851078b7bf499c334e8799f5cee181f1156f9907"
LIC_FILES_CHKSUM = "file://LICENSE;md5=1f1a56bb2dadf5f2be8eb342acf4ed79"
