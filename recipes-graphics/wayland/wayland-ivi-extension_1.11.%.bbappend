INSANE_SKIP_${PN}-dev += "dev-elf"
