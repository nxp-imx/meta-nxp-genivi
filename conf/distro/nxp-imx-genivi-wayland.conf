## conf/distro/nxp-imx-genivi-wayland.conf
```bitbake
# i.MX DISTRO for Genivi Wayland without X11

include conf/distro/fsl-imx-wayland.conf

DISTRO = "nxp-imx-genivi-wayland"
```
