

SRCREV = "b8b3ea3a31f7deb681941a19878c82e7b7350ae7"
SRC_URI_remove = "git://git.projects.genivi.org/${PN}.git;branch=v2.11.x;protocol=http"
SRC_URI_append = " git://git.projects.genivi.org/${BPN}.git;nobranch=1;protocol=http"
